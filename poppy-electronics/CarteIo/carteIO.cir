* EESchema Netlist Version 1.1 (Spice format) creation date: lun. 17 févr. 2014 12:13:38 CET

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

*Sheet Name:/
*Sheet Name:/connector out/
XU12  18 22 0 0 JST
XU11  27 21 10 25 28 26 0 0 USB*2
*Sheet Name:/USB2AX/
C16  9 0 0.1uF
C19  9 0 0.1uF
C18  9 0 4.7uF
GS2  41 61 GS2
K2  0 38 40 CONN_3
TH11  32 40 100R
R13  32 41 150R
D11  0 32 5.1V
R14  39 61 150R
XU4  30 37 0 0 LED-BICOLORE
R15  37 59 150R
R16  31 30 150R
C13  34 0 1uF
C12  46 0 18pF
C11  47 0 18pF
Q1  47 46 16MHz
R12  7 49 22R
R11  8 36 22R
XU3  47 46 0 9 44 43 42 61 41 45 59 31 56 29 55 35 52 51 50 60 58 57 48 54 53 34 0 49 36 9 9 33 ATMEGA32U2
*Sheet Name:/Alim/
D2  133 0 LED
R45  5 133 160
C27  134 0 22uF
XU13  9 5 0 AP1117
C10  132 0 10uF
*Sheet Name:/connectorIn/
R50  9 307 330
D6  307 0 LED
R49  306 309 330
R48  308 304 330
R47  305 310 330
D5  309 0 LED
D4  304 0 LED
D3  310 0 LED
C35  308 0 4.7u
C36  306 0 4.7u
R46  311 0 1k
R51  305 303 1k
Q4  305 311 9 PNP
Q5  308 303 9 PNP
C34  305 0 4.7u
J2  308 2 1 0 USB_2
J1  306 12 3 0 USB_2
P1  0 305 CONN_2
*Sheet Name:/Sensors/
C39  5 0 100n
C40  5 0 100n
C41  278 0 2.2u
C38  5 0 1u
C37  5 0 100n
XU14  293 292 291 277 285 280 281 5 0 282 283 279 5 287 288 289 290 0 302 278 284 286 19 23 ITG-3200
ADXL3501  5 301 300 19 299 23 0 5 298 297 296 295 0 5 294 0 ADXL350
*Sheet Name:/USB2AX2/
C26  9 0 0.1uF
C25  9 0 0.1uF
C24  9 0 4.7uF
GS1  83 81 GS2
K1  0 85 82 CONN_3
TH1  84 82 100R
R23  84 83 150R
D1  0 84 5.1V
R24  76 81 150R
XU2  72 73 0 0 LED-BICOLORE
R25  73 74 150R
R26  75 72 150R
C23  87 0 1uF
C22  64 0 18pF
C21  63 0 18pF
Q2  63 64 16MHz
R22  14 65 22R
R21  15 66 22R
XU1  63 64 0 9 67 68 69 81 83 77 74 75 71 62 78 79 80 93 94 86 92 91 90 89 88 87 0 65 66 9 9 70 ATMEGA32U2
*Sheet Name:/Arduino/
XU16  214 206 0 276 275 JST_3
XU15  207 208 0 274 273 JST_3
C52  254 0 100n
FB1  5 254 FILTER
C46  5 0 100n
C45  138 0 100n
C48  138 0 100n
C50  138 0 100n
C51  138 0 100n
C53  138 0 100n
C49  5 0 100n
C47  5 0 100n
C44  5 0 100n
C43  5 0 100n
C42  5 0 100n
R55  22 5 2.2k
R56  18 5 2.2k
SW3  0 260 SW_PUSH
R60  252 250 330
R61  251 253 330
D8  253 0 LED
D7  250 0 LED
XU17  5 206 214 255 260 261 262 263 264 0 266 267 252 268 251 259 269 270 271 265 XBEE
P2  180 272 156 184 256 0 CONN_6
Q6  258 257 5 MOS_P
SW2  258 5 SW_PUSH
R58  19 5 2.2k
R57  23 5 2.2k
C55  137 0 10u
C54  137 0 100n
FB2  138 137 FILTER
R54  5 247 R
R59  139 0 R
R62  140 0 R
R52  20 150 R
R53  24 166 R
C59  140 0 22pF
C57  136 0 C
C56  135 0 C
X1  135 136 12MHz
C60  149 0 C
C58  142 0 C
X2  142 149 32MHz
SAM3X8E1  221 222 214 206 207 208 209 210 211 138 5 0 245 225 231 197 164 171 147 212 218 241 246 226 232 160 159 172 148 213 219 242 0 137 136 135 166 150 17 140 220 24 20 0 138 0 167 142 149 205 139 5 247 0 233 138 5 0 141 215 138 5 248 228 234 161 168 143 151 18 238 237 249 0 254 162 169 144 152 216 239 243 230 229 235 23 19 145 153 217 240 244 224 223 236 163 170 146 154 155 165 189 188 138 5 0 178 180 184 156 189 193 198 202 174 176 179 181 185 157 190 194 199 138 5 0 173 182 186 258 191 195 200 203 175 177 193 183 187 158 192 196 201 204 AT91SAM3X8E
*Sheet Name:/Arduino/programmation/
XU19  0 338 0 222 5 SN74LVC1G125
C67  5 0 100n
C66  9 0 100n
C65  9 0 100n
C64  9 0 100n
R67  167 331 10k
R66  17 325 1k
R68  0 330 10k
D9  314 9 DIODE
R65  9 314 22R
R69  9 313 22R
R70  9 312 22R
D12  312 318 LED
D10  313 337 LED
P3  324 9 328 326 314 0 CONN_6
C63  315 0 22p
X3  334 336 12MHz 20pF
C62  336 0 22p
C61  334 0 22p
R64  335 2 22R
R63  1 320 22R
XU18  334 336 0 9 323 316 317 159 338 318 337 332 330 329 328 326 324 322 321 319 333 331 257 327 325 315 0 320 335 9 9 314 ATMEGA16U2
*Sheet Name:/USBHUB/
R74  16 131 330
R73  21 104 330
R72  27 130 330
R71  17 105 330
D16  131 0 LED
D15  104 0 LED
D14  130 0 LED
D13  105 0 LED
C71  9 0 100n
C70  5 0 4.7u
C69  5 0 4.7u
C68  5 0 4.7u
XU6  0 9 103 119 0 9 123 122 129 16 21 101 121 27 17 102 TPS2044
C4  0 115 100n
C1  3 0 22p
SW1  0 115 SW_PUSH
R4  115 5 10k
C3  125 0 27p
C5  126 0 27p
C2  12 0 22p
R1  3 114 27R
R2  12 113 27R
R3  111 114 1.5k
Q3  125 126 6MHz
XU5  111 114 113 0 115 127 5 5 5 128 118 109 96 120 117 108 97 103 102 107 98 119 0 121 100 99 123 101 106 95 122 129 110 116 122 129 112 124 0 126 125 5 5 0 TUSB2077
*Sheet Name:/USBHUB/USBFilter/
XU10  0 114 0 113 0 13 0 4 SN75240
XU9  0 6 0 11 0 25 0 26 SN75240
XU8  0 28 0 10 0 20 0 24 SN75240
XU7  0 7 0 8 0 15 0 14 SN75240
C14  98 0 22pF
R9  98 24 27R
R29  24 0 15k
R30  20 0 15k
R10  107 20 27R
C15  107 0 22pF
C20  100 0 22pF
R18  100 10 27R
R32  10 0 15k
R31  28 0 15k
R17  99 28 27R
C17  99 0 22pF
C33  112 0 22pF
R38  112 13 27R
R44  13 0 15k
R43  4 0 15k
R37  124 4 27R
C32  124 0 22pF
C28  95 0 22pF
R33  95 26 27R
R39  26 0 15k
R40  25 0 15k
R34  106 25 27R
C29  106 0 22pF
C31  110 0 22pF
R36  110 11 27R
R42  11 0 15k
R41  6 0 15k
R35  116 6 27R
C30  116 0 22pF
C8  97 0 22pF
R7  97 7 27R
R27  7 0 15k
R28  8 0 15k
R8  108 8 27R
C9  108 0 22pF
C7  109 0 22pF
R6  109 15 27R
R20  15 0 15k
R19  14 0 15k
R5  96 14 27R
C6  96 0 22pF

.end
